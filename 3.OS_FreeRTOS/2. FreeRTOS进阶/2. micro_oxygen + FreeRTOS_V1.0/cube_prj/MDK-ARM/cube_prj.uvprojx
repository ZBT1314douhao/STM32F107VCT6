# Keil uVision project cube_prj.uvprojx, settings and files
target cube_prj (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cube_prj
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ..\..\STemWinLibrary522\Config;  ..\..\STemWinLibrary522\Font;  ..\..\STemWinLibrary522\Touch;  ..\..\STemWinLibrary522\Lib;  ..\..\STemWinLibrary522\inc;  ..\..\user_lib;  ..\..\user_interface
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_crc.c stm32f1xx_hal_tim.c stm32f1xx_hal_adc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/User
    ../../user_lib/: adc_app.c delay.c exti_dup.c key.c lcd_ssd1289.c led.c rtc_dup.c tim_dup.c touch.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: rtc.c adc.c gpio.c stm32f1xx_hal_msp.c crc.c dma.c main.c spi.c tim.c stm32f1xx_it.c freertos.c usart.c stm32f1xx_hal_timebase_TIM.c
  group Application/User/Interface
    ../../user_interface/: adjust_time_window.c measure_window.c start_window.c sys_info_window.c ui_drivers.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c list.c timers.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group STemwin/Config
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/OS/: GUI_X.c
  group STemwin/Touch
    ../../STemWinLibrary522/Touch/: GUI_X_Touch_Analog.c TOUCH_Sample.c
  group STemwin/Font
    ../../STemWinLibrary522/Font/: Button_YaHei_Mono18.c FounderMiaoWu28.c Microsoft YaHei Mono28.c YaHei_Mono28.c
  group Docs/Readme
    ../../Docs/: readme.txt update_log.txt
software components: CMSIS:CORE 4.1.0
