# Keil uVision project cube_prj.uvprojx, settings and files
target cube_prj (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cube_prj +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --diag_suppress=870
  c include: ../Inc;              ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;              ../Drivers/STM32F1xx_HAL_Driver/Inc;              ../Drivers/CMSIS/Include;              ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;              ..\..\user_lib;              ..\..\STemWinLibrary522\Config;              ..\..\STemWinLibrary522\OS;              ..\..\STemWinLibrary522\inc;              ..\..\STemWinLibrary522\Touch;              ..\..\Demo;              ..\..\user_interface; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c
  group Drivers/User
    ../../user_lib/: delay.c key.c led.c exti_dup.c tim_dup.c lcd_ssd1289.c touch.c rtc_dup.c adc_app.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c main.c crc.c spi.c tim.c rtc.c adc.c dma.c freertos.c stm32f1xx_hal_timebase_TIM.c
  group STemwin
    ../../STemWinLibrary522/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../STemWinLibrary522/OS/: GUI_X.c GUI_X_FreeRTOS.c
  group STemwin/Demo
    ../../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group STemwin/Touch
    ../../STemWinLibrary522/Touch/: GUI_X_Touch_Analog.c TOUCH_Sample.c
  group User_Interface
    ../../user_interface/: start_window.c ui_drivers.c measure_window.c adjust_time_window.c sys_info_window.c
  group STemwin/Font
    ../../STemWinLibrary522/Font/: Microsoft YaHei Mono28.c YaHei_Mono28.c Button_YaHei_Mono18.c FounderMiaoWu28.c
  group Docs
    ../../Docs/: readme.txt update_log.txt
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c queue.c list.c timers.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
